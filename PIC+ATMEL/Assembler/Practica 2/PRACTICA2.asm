	MOV 	P1, #33H
	MOV 	R6, #25H;
AQUI:	JNB	P3.5, AQUI;	Espera un 1
	DJNZ	R6,AQUI;
	MOV 	A, P3
	CLR	A.5
	CLR	A.6
	CLR	A.7
	MOV	R0, A
	MOV	DPTR, #2000H
	MOV 	R7, #25H
OTRA:	MOVX	@DPTR, A
	DJNZ	R7, OTRA
	MOV	P1, A
	MOV 	R6, #020H;
AQUI2:	JB	P3.5, AQUI2;	Espera un 0
	DJNZ	R6,AQUI2;
	MOV 	A, P3
	CLR	A.5
	CLR	A.6
	CLR	A.7
	MOV	R1, A
	MOV	DPTR, #2001H
	MOV R7, #25H
OTRA2:	MOVX	@DPTR, A
	DJNZ	R7, OTRA2
	MOV	P1, A
	MOV 	R6, #020H;
AQUI3:	JNB	P3.5, AQUI3;	Espera un 1
	DJNZ	R6,AQUI3;
	MOV 	A, P3
	CLR	A.5
	CLR	A.6
	CLR	A.7
	MOV	R2, A
	MOV	DPTR, #2002H
	MOV R7, #25H
OTRA3:	MOVX	@DPTR, A
	DJNZ	R7, OTRA3
	MOV	P1, A
AQUI4:	JB	P3.5, AQUI4
	MOV	A, R0
	SUBB	A,R1
	JC	YMAYORX
	JNC	XMAYORY
YMAYORX:MOV	A, R1
	SUBB	A,R2
	JC	ZMAYORY
	JNC	YMAYORZ
XMAYORY:MOV	A,R0
	SUBB	A,R2
	JC	ZMAYORX
	JNC	XMAYORZ
ZMAYORY:MOV	P1, R2
	LJMP	FIN
YMAYORZ:MOV	P1, R1
	LJMP	FIN
ZMAYORX:MOV	P1,R2
	LJMP	FIN
XMAYORZ:MOV	P1, R0
	LJMP	FIN
FIN:	LJMP	FIN
END