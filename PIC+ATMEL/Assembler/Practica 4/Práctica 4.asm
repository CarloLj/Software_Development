	MOV	P1,#33H
	MOV	R0,#02H
	LCALL	LEER
	MOV	R0,#03H
	LCALL	LEER
	MOV	R7,#25H
LEERZ:	JNB	P3.5, LEERZ
	DJNZ	R7,LEERZ
	MOV	A,P3
	ANL	A,#03H
	MOV	R4,A
;EMPIEZA EL SWITCH
	CJNE	R4, #00H, CASO1
	LCALL	CASE0
	LJMP 	FIN
CASO1:	CJNE	R4,#01H,CASO2	;CASO 2
	LCALL 	CASE1
	LJMP	FIN
CASO2:	CJNE	R4,#02H,FIN
	LCALL	CASE2
FIN:	LJMP	FIN
;TERMINA EL MAIN

LEER:	MOV	R7,#25H
BAJA:	JNB	P3.5,BAJA
	DJNZ	R7,BAJA
	MOV	A,P3
	ANL	A,#0FH
	MOV	P1,A
	MOV	R1,A
	MOV	R7,#25H
ALTA:	JB	P3.5,ALTA
	DJNZ	R7,ALTA
	MOV	A,P3
	ANL	A,#0FH
	SWAP	A
	ADD	A,R1
	MOV	@R0,A
	MOV	P1,@R0
	RET


CASE0:	MOV	A,R2
	MOV	B,R2
	MUL	AB
	MOV	30H,A
	MOV	31H,B
	MOV	A,R3
	MOV	B,R3
	MUL 	AB
	MOV	32H,A
	MOV	33H,B
	MOV	A,30H
	MOV	B,32H
	MUL	AB
	MOV	34H,A
	MOV	35H,B
	MOV	A,31H
	MOV	B,32H
	MUL	AB
	MOV	36H,A
	MOV	37H,B
	MOV	A,30H
	MOV	B,33H
	MUL	AB
	MOV	38H,A
	MOV	39H,B
	MOV	A,31H
	MOV	B,33H
	MUL	AB
	MOV	3AH,A
	MOV	3BH,B
	MOV	3CH,34H;	MUEVE RES1
	MOV	A,35H
	ADD	A,36H
	ADD	A,38H
	MOV	3DH,A;		;MOVER LA SUMA A RES2
	JNC	RES		; SI HAY CARRY AÑADIR 1 A RES3
	MOV	A,3EH
	INC 	A
	MOV	3EH,A
	CLR 	C
RES:			
	MOV	A,37H
	ADD	A,39H
	ADD	A,3AH
	ADD	A,3EH		;LE SUMA EL CARRY A RES3
	MOV	3EH,A		;MOVER LA SUMA A RES3
	JNC	RES2
	MOV	A,3FH;		SI HAY CARRY AÑADE A RES4
	INC 	A
	MOV	3FH,A
	CLR 	C
RES2:	MOV	A,3BH	;MUEVE A 
	ADD	A,3FH
	MOV	3FH,A
;COMIENZA A MOSTRAR LOS NUMEROS
	MOV	R7,#25H
MUESTRA:JB	P3.5,MUESTRA
	DJNZ	R7,MUESTRA
	MOV	P1,3CH
	MOV	R7,#25H
MUESTR:	JNB	P3.5,MUESTR
	DJNZ	R7,MUESTR
	MOV	P1,3DH
	MOV	R7,#25H
MUEST:	JB	P3.5,MUEST
	DJNZ	R7,MUEST
	MOV	P1,3EH
	MOV	R7,#25H
MUES:	JNB	P3.5,MUES
	DJNZ	R7,MUES
	MOV	P1,3FH
	RET

CASE1:	MOV	P1,#01H
	LCALL RETARD
	MOV	B,#52H
	MOV	A,R2
	MUL	AB
	SUBB	A,R3
	MOV	47H,A
	JNC	CASE_1
	DEC	B
CASE_1: MOV	48H,B
	MOV	R0,#46H
	INC	R0
	MOV	R7,#25H
	LCALL	MUESTRA
	INC	R0
	MOV	R7,#25H
	LCALL 	MUESTR
	RET


CASE2:	MOV	P1,#02H
	LCALL RETARD
	CJNE	R3,#00H,GOOD
	MOV	A,#01H;
	MOV	R0,#64D;
LOOP5:	RR	A;
	MOV	P1,A;
	LCALL 	RETARD;
	DJNZ	R0,LOOP5;
	LJMP	FIN;
GOOD:	MOV	A,R2
	MOV	B,R2
	MUL	AB
	MOV	30H, A
	MOV	31H, B
	MOV	B,#0FFH
CONSEC:	INC	B
	CLR	C	
	SUBB	A,R3
	JNC	CONSEC
	CLR	C
	MOV	R1,31H
	DEC	R1
	MOV	31H,R1
	CJNE	R1,#0FFH,CONSEC
	MOV	P1,B
	RET
	

RETARD:	MOV	R5,#08D;
CETI3:	MOV	R6,#250D;
CETI2:	MOV	R7,#250D;
CETI:	DJNZ	R7,CETI;
	DJNZ	R6,CETI2;
	RET

	


	
	